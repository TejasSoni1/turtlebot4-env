Commit message: Enable full TurtleBot4 nav stack

File: src/gazebo/launch/robot.urdf (robot description, URDF)
Before this commit: robot robot, 4 links, 0 joints
Links:
- removed link robot/caster
- removed link robot/chassis
- removed link robot/left_wheel
- removed link robot/right_wheel
